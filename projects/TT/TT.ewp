# IAR project TT.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: LPC2378 NXP LPC2378
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 1
  General.FPU2: 0
  ICCARM.CCDefines: IAR_LPC_2378_SK
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\INC\NXP; include; ..\..\bsp\include; ..\..\TTSched\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $TOOLKIT_DIR$\INC\NXP; include\app; include\os; ..\..\bsp\include; ..\..\FreeRTOS\Source\include; ..\..\FreeRTOS\Source\portable\IAR\LPC2000
  OBJCOPY.OOCOutputFile: a.srec
  ILINK.IlinkOutputFile: a.out
  ILINK.IlinkIcfFile: config\LPC2378_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app/include
    include/: ttSchedConfig.h
  group app/src
    src/: main.c
  group bsp/include
    ../../bsp/include/: accelerometer.h adc.h arm_comm.h board.h bsp.h buttons.h can.h delay.h drv_glcd.h drv_glcd_cnfg.h glcd_ll.h lcd.h leds.h median_filter.h potentiometer.h pwm.h timers.h
  group bsp/src
    ../../bsp/src/: accelerometer.c adc.c bsp.c buttons.c can.c delay.c lcd.c leds.c median_filter.c potentiometer.c timers.c
  group bsp/src/lcd
    ../../bsp/src/lcd/: drv_glcd.c glcd_ll.c
  group bsp/src/lcd/fonts
    ../../bsp/src/lcd/fonts/: Terminal_9_12x6.c
  group TTSched/include
    ../../TTSched/include/: scheduler.h
  group TTSched/src
    ../../TTSched/src/: scheduler.c
