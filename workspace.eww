<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\projects\ET\ET.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\projects\TT\TT.ewp</path>
  </project>
  <batchBuild/>
</workspace>


